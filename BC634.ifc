Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-05-15T10:21:38
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 15 10:21:38 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{BA756F9A-3DB1-494C-9A57-C9FA62CE57E5}\ifc * Database version: 5507 * Database creation date: Wed May 15 10:21:37 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 15 10:21:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 15 10:21:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\05$MAY\BC634.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Weight: 1; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: BC634 Dolphin Behind Mirror Soap Dispenser, BC634:BC634 Dolphin Behind Mirror Soap Dispenser:18200
In: Level 1
Material: Stainless Steel, Pipe, Bracket, Glass
Constraints - Level: Level: Level 1; Offset: 0 mm; Moves With Nearby Elements: no; Host: Level : Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.000460791 m3; Height above counter: Minimum height above surface below 300mm; Projection: 140mm (Minimum cavity); Height: Allow overal height from bottom of baseplate 400mm; Width: 140mm; Clearances: Minimum of 200mm in front of soap bottle to allow for refill.
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Limited
Pset_BuildingElementProxyCommon - Reference: BC634 Dolphin Behind Mirror Soap Dispenser
Identity Data - Assembly Code: D2090900; Email: info@dolphinsolutions.co.uk; Address: Southpoint, Compass Park, Bodiam, Robertsbridge, TN32 5BS; Fax No.: +44 (0) 1424 205200; Manufacturer: Dolphin Solutions Limited; URL: www.dolphinsolutions.co.uk; Model: BC634; Tel No.: +44 (0) 1424 202224; Assembly Description: Misc. Other Plumbing Systems; Description: Behind mirror soap dispenser
General - Parts Listing: https://www.dolphinsolutions.co.uk/en/product/behind-mirror-soap-dispenser-2/download-single-pdf/pdf_uploads/1; Do's and Dont's: https://www.dolphinsolutions.co.uk/en/product/dolphin-panel-mounted-infra-red-soap-dispenser-2/download-single-pdf/pdf_uploads/1; Product Page Link: http://www.dolphinsolutions.co.uk/en/product/behind-mirror-soap-dispenser-2; Product Data: Easy to fit behind mirror infrared soap dispenser for contemporary washroom design with an uncluttered appearance. Designed to be fitted behind hinged mirror or panel (access required to replenish soap supply). Touch-free – thus eliminating cross-contamination. Capacity 1,000 ml. 1.8ml of soap per dispensing cycle – adjustable on-site with Dolphin key ring. Helps prevent vandalism – vandal resistant. Powered by 12v transformer. Draws maximum current of 0.5A at sensor activation. Chrome plated nozzle designed to protrude slightly below bottom edge of mirror making it quick and easy to identify and use. 1,000ml refillable plastic container (no need to purchase unique soap reservoirs). 2 year guarantee.The peristaltic pump allows the use of different soap viscosities, including antibacterial gels. Easy to use refill button (either on the dispenser pump, or by means of the Remote Control) - use window in baseplate for checking soap levels. Backplate made from stainless steel. Power connections: soap dispenser: female / power source: male.; Installation and Maintenance Guide: https://www.dolphinsolutions.co.uk/en/product/dolphin-panel-mounted-infra-red-soap-dispenser-2/download-single-pdf/pdf_uploads/0; Warranty: 2 years manufacturer's warranty
Electrical - Power Supplies and Connectors: https://www.dolphinsolutions.co.uk/en/product/dolphin-panel-mounted-infra-red-soap-dispenser-2/download-single-pdf/pdf_uploads/2; Power Source: 12 Volt transformer. Draws maximumu current of 0.5A at sensor activation
